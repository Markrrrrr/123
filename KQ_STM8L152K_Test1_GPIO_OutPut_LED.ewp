# IAR project KQ_STM8L152K_Test1_GPIO_OutPut_LED.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152R8 STM8L152R8
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; SDCARD; src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: KQ_STM8L152K_Test1_GPIO_OutPut_LED.bin
  ILINK.IlinkOutputFile: KQ_STM8L152K_Test1_GPIO_OutPut_LED.out
  ILINK.IlinkIcfFile: F:\单片机例程\1.程序\IAP\其他参考例程\STM8L152R8T6\STM8L152测试TSM121-APP-3\lnkstm8l152r8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: AT24C02.c i2cDs1307.c main.c oled.c TSM12.c
  group FATFS
    src/: diskio.c ff.c
    SDCARD/: FSCTR.c MMC_SD.C spi.c
