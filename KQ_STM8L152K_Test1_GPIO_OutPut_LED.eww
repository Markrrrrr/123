<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\KQ_STM8L152K_Test1_GPIO_OutPut_LED.ewp</path>
  </project>
  <batchBuild/>
</workspace>


